# Keil uVision project 读出DS18B20的温度.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 读出DS18B20的温度 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 读出DS18B20的温度.c
