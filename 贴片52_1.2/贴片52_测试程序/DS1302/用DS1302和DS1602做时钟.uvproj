# Keil uVision project 用DS1302和DS1602做时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 用DS1302和DS1602做时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 用DS1302和DS1602做时钟.c
